# Keil uVision project NewDevice.uvproj, settings and files
target Cortex-M (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Stack Size
    ./: FlashStk.s
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
